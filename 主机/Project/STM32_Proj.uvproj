# Keil uVision project STM32_Proj.uvproj, settings and files
target STM32F103ZE (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_Proj +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\Source\main;..\Source\Dev;..\Source\Att;..\Source\lcd;..\Source\IIC;..\Source\USART2_HMI;..\Source\ZigBee
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../Libraries/FWlib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_tim.c
  group Main
    ../Source/main/: main.c stm32f10x_it.c
    ../Source/Main/: system.c config.h RemapGPIO.h
  group Dev
    ../Source/Dev/: Usart.c Queue.c SysTick.c Button.c Timer.c SPI.c
  group Att
    ../Source/Att/: ATT7022.C ATT7022.H
  group EEPROM
    ../Source/IIC/: AT24C02.c I2C.c
  group HMI
    ../Source/USART2_HMI/: usart2_HMI.c
  group ZigBee
    ../Source/ZigBee/: usart3_ZigBee.c
